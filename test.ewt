<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <file>
    <name>$PROJ_DIR$\cc2530_rf.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\cc2530_spi.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\cc2530_timer1.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\cc2530_usart.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\delay_8051.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\I2Cdev.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\logClass.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main_accel_myfilter.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\motionProcessor.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\MPU6050.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\packetProcessor.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\QueueClass.cpp</name>
  </file>
  <file>
    <name>$PROJ_DIR$\TableClass.cpp</name>
  </file>
</project>


